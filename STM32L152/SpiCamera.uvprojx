# Keil uVision project SpiCamera.uvprojx, settings and files
target Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SpiCamera
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L1XX_MD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\HARDWARE\ArduCAM;.\HARDWARE\I2C;.\HARDWARE\SPI;.\STM32L1xx_StdPeriph_Driver\inc;.\SYSTEM\delay;.\SYSTEM\usart;.\User
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CORE
    ./CORE/: system_stm32l1xx.c startup_stm32l1xx_md.s
  group HARDWARE
    ./HARDWARE/ArduCAM/: ArduCAM.c
    ./HARDWARE/I2C/: sccb_bus.c
    ./HARDWARE/SPI/: spi.c
  group STD_Drive
    ./STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/usart/: usart.c
  group User
    ./User/: main.c stm32l1xx_it.c
